# Keil uVision project project.uvproj, settings and files
target project (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: project +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\StdPeriphDriver\inc;.\Users;.\app\led;.\app\key;.\app\system;.\app\usart;.\app\lcd;.\app\flash;.\app\spi;.\app\gui
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ./CMSIS/: system_stm32f10x.c core_cm3.c
  group StdPeriphDriver
    ./StdPeriphDriver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_spi.c
  group StartUp
    ./StartUp/: startup_stm32f10x_hd.s
  group app
    ./app/system/: system.c
    ./app/key/: key.c
    ./app/led/: led.c
    ./app/flash/: flash.c
    ./app/spi/: spi.c
    ./app/gui/: gui.c
    ./app/lcd/: lcd_driver.c
  group User
    ./Users/: main.c stm32f10x_it.c
